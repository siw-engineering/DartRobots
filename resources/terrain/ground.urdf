Commit message: Increase default ground size

File: resources/terrain/ground.urdf (robot description, URDF)
Before this commit: robot ground_skeleton, 2 links, 1 joints
Links:
- link ground_link: geometry collision box size=100 100 0.02; visual box size=100 100 0.02
